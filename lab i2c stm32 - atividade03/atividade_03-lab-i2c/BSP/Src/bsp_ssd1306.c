/**
 * @file    bsp_ssd1306.c
 * @brief   Driver do SSD1306: framebuffer, primitivas graficas e fonte 5x7.
 * @ingroup BSP_SSD1306
 */
#include "bsp_ssd1306.h"
#include "bsp_i2c.h"
#include <stdlib.h>
#include <string.h>

#define CTRL_CMD   0x00U /**< Byte de controle: os proximos bytes sao comandos */
#define CTRL_DATA  0x40U /**< Byte de controle: os proximos bytes sao dados    */
#define PAGES      (BSP_SSD1306_HEIGHT / 8)

/** @brief Framebuffer: s_fb[pagina][coluna], bit 0 = linha superior da pagina. */
static uint8_t s_fb[PAGES][BSP_SSD1306_WIDTH];
/** @brief Proxima pagina a ser enviada por @ref bsp_ssd1306_update_step. */
static uint8_t s_page;

/** @brief Sequencia de inicializacao (modulo 128x64 com charge pump interno). */
static const uint8_t s_init_seq[] = {
    0xAE,       /* display OFF                                   */
    0xD5, 0x80, /* divisor de clock / frequencia do oscilador    */
    0xA8, 0x3F, /* multiplex ratio = 64 linhas                   */
    0xD3, 0x00, /* display offset = 0                            */
    0x40,       /* linha inicial = 0                             */
    0x8D, 0x14, /* habilita o charge pump                        */
    0x20, 0x02, /* modo de enderecamento por pagina              */
    0xA1,       /* remapeia colunas (coluna 127 -> SEG0)         */
    0xC8,       /* varredura COM invertida (imagem "em pe")      */
    0xDA, 0x12, /* configuracao dos pinos COM                    */
    0x81, 0xCF, /* contraste                                     */
    0xD9, 0xF1, /* periodo de pre-carga                          */
    0xDB, 0x40, /* nivel de VCOMH                                */
    0xA4,       /* exibe o conteudo da RAM                       */
    0xA6,       /* modo normal (nao invertido)                   */
    0x2E,       /* desliga scroll                                */
    0xAF        /* display ON                                    */
};

/**
 * @brief Fonte 5x7: 5 colunas por glifo, bit 0 = linha superior.
 *        Indices 0..94 = ASCII 0x20..0x7E; indice 95 = simbolo de grau.
 */
static const uint8_t s_font[96][5] = {
    {0x00,0x00,0x00,0x00,0x00}, /* ' ' */ {0x00,0x00,0x5F,0x00,0x00}, /* ! */
    {0x00,0x07,0x00,0x07,0x00}, /* " */   {0x14,0x7F,0x14,0x7F,0x14}, /* # */
    {0x24,0x2A,0x7F,0x2A,0x12}, /* $ */   {0x23,0x13,0x08,0x64,0x62}, /* % */
    {0x36,0x49,0x55,0x22,0x50}, /* & */   {0x00,0x05,0x03,0x00,0x00}, /* ' */
    {0x00,0x1C,0x22,0x41,0x00}, /* ( */   {0x00,0x41,0x22,0x1C,0x00}, /* ) */
    {0x08,0x2A,0x1C,0x2A,0x08}, /* * */   {0x08,0x08,0x3E,0x08,0x08}, /* + */
    {0x00,0x50,0x30,0x00,0x00}, /* , */   {0x08,0x08,0x08,0x08,0x08}, /* - */
    {0x00,0x60,0x60,0x00,0x00}, /* . */   {0x20,0x10,0x08,0x04,0x02}, /* / */
    {0x3E,0x51,0x49,0x45,0x3E}, /* 0 */   {0x00,0x42,0x7F,0x40,0x00}, /* 1 */
    {0x42,0x61,0x51,0x49,0x46}, /* 2 */   {0x21,0x41,0x45,0x4B,0x31}, /* 3 */
    {0x18,0x14,0x12,0x7F,0x10}, /* 4 */   {0x27,0x45,0x45,0x45,0x39}, /* 5 */
    {0x3C,0x4A,0x49,0x49,0x30}, /* 6 */   {0x01,0x71,0x09,0x05,0x03}, /* 7 */
    {0x36,0x49,0x49,0x49,0x36}, /* 8 */   {0x06,0x49,0x49,0x29,0x1E}, /* 9 */
    {0x00,0x36,0x36,0x00,0x00}, /* : */   {0x00,0x56,0x36,0x00,0x00}, /* ; */
    {0x08,0x14,0x22,0x41,0x00}, /* < */   {0x14,0x14,0x14,0x14,0x14}, /* = */
    {0x00,0x41,0x22,0x14,0x08}, /* > */   {0x02,0x01,0x51,0x09,0x06}, /* ? */
    {0x32,0x49,0x79,0x41,0x3E}, /* @ */   {0x7E,0x11,0x11,0x11,0x7E}, /* A */
    {0x7F,0x49,0x49,0x49,0x36}, /* B */   {0x3E,0x41,0x41,0x41,0x22}, /* C */
    {0x7F,0x41,0x41,0x22,0x1C}, /* D */   {0x7F,0x49,0x49,0x49,0x41}, /* E */
    {0x7F,0x09,0x09,0x09,0x01}, /* F */   {0x3E,0x41,0x49,0x49,0x7A}, /* G */
    {0x7F,0x08,0x08,0x08,0x7F}, /* H */   {0x00,0x41,0x7F,0x41,0x00}, /* I */
    {0x20,0x40,0x41,0x3F,0x01}, /* J */   {0x7F,0x08,0x14,0x22,0x41}, /* K */
    {0x7F,0x40,0x40,0x40,0x40}, /* L */   {0x7F,0x02,0x0C,0x02,0x7F}, /* M */
    {0x7F,0x04,0x08,0x10,0x7F}, /* N */   {0x3E,0x41,0x41,0x41,0x3E}, /* O */
    {0x7F,0x09,0x09,0x09,0x06}, /* P */   {0x3E,0x41,0x51,0x21,0x5E}, /* Q */
    {0x7F,0x09,0x19,0x29,0x46}, /* R */   {0x46,0x49,0x49,0x49,0x31}, /* S */
    {0x01,0x01,0x7F,0x01,0x01}, /* T */   {0x3F,0x40,0x40,0x40,0x3F}, /* U */
    {0x1F,0x20,0x40,0x20,0x1F}, /* V */   {0x3F,0x40,0x38,0x40,0x3F}, /* W */
    {0x63,0x14,0x08,0x14,0x63}, /* X */   {0x07,0x08,0x70,0x08,0x07}, /* Y */
    {0x61,0x51,0x49,0x45,0x43}, /* Z */   {0x00,0x7F,0x41,0x41,0x00}, /* [ */
    {0x02,0x04,0x08,0x10,0x20}, /* \ */   {0x00,0x41,0x41,0x7F,0x00}, /* ] */
    {0x04,0x02,0x01,0x02,0x04}, /* ^ */   {0x40,0x40,0x40,0x40,0x40}, /* _ */
    {0x00,0x01,0x02,0x04,0x00}, /* ` */   {0x20,0x54,0x54,0x54,0x78}, /* a */
    {0x7F,0x48,0x44,0x44,0x38}, /* b */   {0x38,0x44,0x44,0x44,0x20}, /* c */
    {0x38,0x44,0x44,0x48,0x7F}, /* d */   {0x38,0x54,0x54,0x54,0x18}, /* e */
    {0x08,0x7E,0x09,0x01,0x02}, /* f */   {0x0C,0x52,0x52,0x52,0x3E}, /* g */
    {0x7F,0x08,0x04,0x04,0x78}, /* h */   {0x00,0x44,0x7D,0x40,0x00}, /* i */
    {0x20,0x40,0x44,0x3D,0x00}, /* j */   {0x7F,0x10,0x28,0x44,0x00}, /* k */
    {0x00,0x41,0x7F,0x40,0x00}, /* l */   {0x7C,0x04,0x18,0x04,0x78}, /* m */
    {0x7C,0x08,0x04,0x04,0x78}, /* n */   {0x38,0x44,0x44,0x44,0x38}, /* o */
    {0x7C,0x14,0x14,0x14,0x08}, /* p */   {0x08,0x14,0x14,0x18,0x7C}, /* q */
    {0x7C,0x08,0x04,0x04,0x08}, /* r */   {0x48,0x54,0x54,0x54,0x20}, /* s */
    {0x04,0x3F,0x44,0x40,0x20}, /* t */   {0x3C,0x40,0x40,0x20,0x7C}, /* u */
    {0x1C,0x20,0x40,0x20,0x1C}, /* v */   {0x3C,0x40,0x30,0x40,0x3C}, /* w */
    {0x44,0x28,0x10,0x28,0x44}, /* x */   {0x0C,0x50,0x50,0x50,0x3C}, /* y */
    {0x44,0x64,0x54,0x4C,0x44}, /* z */   {0x00,0x08,0x36,0x41,0x00}, /* { */
    {0x00,0x00,0x7F,0x00,0x00}, /* | */   {0x00,0x41,0x36,0x08,0x00}, /* } */
    {0x08,0x04,0x08,0x10,0x08}, /* ~ */   {0x00,0x06,0x09,0x09,0x06}  /* grau */
};

/** @brief Envia uma pagina do framebuffer (posiciona o cursor e manda 128 bytes). */
static bool send_page(uint8_t page)
{
    const uint8_t cmd[3] = {
        (uint8_t)(0xB0U | page),                          /* pagina          */
        (uint8_t)(0x00U | (BSP_SSD1306_X_OFFSET & 0x0FU)),/* coluna, nibble L */
        (uint8_t)(0x10U | (BSP_SSD1306_X_OFFSET >> 4))    /* coluna, nibble H */
    };

    if (!bsp_i2c_write_reg(BSP_SSD1306_ADDR, CTRL_CMD, cmd, sizeof(cmd)))
    {
        return false;
    }
    return bsp_i2c_write_reg(BSP_SSD1306_ADDR, CTRL_DATA, s_fb[page],
                             BSP_SSD1306_WIDTH);
}

bool bsp_ssd1306_init(void)
{
    s_page = 0U;
    bsp_ssd1306_clear();

    if (!bsp_i2c_is_ready(BSP_SSD1306_ADDR))
    {
        return false;
    }
    if (!bsp_i2c_write_reg(BSP_SSD1306_ADDR, CTRL_CMD, s_init_seq,
                           sizeof(s_init_seq)))
    {
        return false;
    }
    return bsp_ssd1306_update();
}

void bsp_ssd1306_clear(void)
{
    memset(s_fb, 0, sizeof(s_fb));
}

void bsp_ssd1306_pixel(int x, int y, bool on)
{
    if ((x < 0) || (x >= BSP_SSD1306_WIDTH) || (y < 0) || (y >= BSP_SSD1306_HEIGHT))
    {
        return;
    }
    if (on)
    {
        s_fb[y >> 3][x] |= (uint8_t)(1U << (y & 7));
    }
    else
    {
        s_fb[y >> 3][x] &= (uint8_t)~(1U << (y & 7));
    }
}

void bsp_ssd1306_line(int x0, int y0, int x1, int y1)
{
    int dx  = abs(x1 - x0);
    int dy  = -abs(y1 - y0);
    int sx  = (x0 < x1) ? 1 : -1;
    int sy  = (y0 < y1) ? 1 : -1;
    int err = dx + dy;

    for (;;)
    {
        bsp_ssd1306_pixel(x0, y0, true);
        if ((x0 == x1) && (y0 == y1))
        {
            break;
        }
        int e2 = 2 * err;
        if (e2 >= dy) { err += dy; x0 += sx; }
        if (e2 <= dx) { err += dx; y0 += sy; }
    }
}

void bsp_ssd1306_circle(int cx, int cy, int r)
{
    int x = r;
    int y = 0;
    int err = 1 - r;

    while (x >= y)
    {
        bsp_ssd1306_pixel(cx + x, cy + y, true);
        bsp_ssd1306_pixel(cx + y, cy + x, true);
        bsp_ssd1306_pixel(cx - y, cy + x, true);
        bsp_ssd1306_pixel(cx - x, cy + y, true);
        bsp_ssd1306_pixel(cx - x, cy - y, true);
        bsp_ssd1306_pixel(cx - y, cy - x, true);
        bsp_ssd1306_pixel(cx + y, cy - x, true);
        bsp_ssd1306_pixel(cx + x, cy - y, true);
        y++;
        if (err < 0)
        {
            err += 2 * y + 1;
        }
        else
        {
            x--;
            err += 2 * (y - x) + 1;
        }
    }
}

void bsp_ssd1306_char(int x, int y, char c)
{
    uint8_t uc = (uint8_t)c;
    if ((uc < 0x20U) || (uc > 0x7FU))
    {
        uc = (uint8_t)'?';
    }
    const uint8_t *glyph = s_font[uc - 0x20U];

    for (int col = 0; col < BSP_SSD1306_CHAR_W; col++)
    {
        uint8_t bits = (col < 5) ? glyph[col] : 0x00U; /* 6a coluna = espaco */
        for (int row = 0; row < BSP_SSD1306_CHAR_H; row++)
        {
            bsp_ssd1306_pixel(x + col, y + row, ((bits >> row) & 1U) != 0U);
        }
    }
}

void bsp_ssd1306_string(int x, int y, const char *s)
{
    while (*s != '\0')
    {
        bsp_ssd1306_char(x, y, *s++);
        x += BSP_SSD1306_CHAR_W;
    }
}

bool bsp_ssd1306_update(void)
{
    bool ok = true;
    for (uint8_t p = 0U; p < PAGES; p++)
    {
        ok = send_page(p) && ok;
    }
    s_page = 0U;
    return ok;
}

bool bsp_ssd1306_update_step(void)
{
    (void)send_page(s_page);   /* falhas ficam em bsp_i2c_error_count() */
    s_page++;
    if (s_page >= PAGES)
    {
        s_page = 0U;
        return true;
    }
    return false;
}
